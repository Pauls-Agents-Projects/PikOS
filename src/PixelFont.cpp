#include "PixelFont.h"

namespace pixelos {
namespace {

Glyph makeGlyph(uint8_t width, uint8_t r0, uint8_t r1, uint8_t r2,
                uint8_t r3, uint8_t r4, uint8_t r5, uint8_t r6) {
  Glyph result{width, {r0, r1, r2, r3, r4, r5, r6}};
  return result;
}

void appendCodepoint(String& output, uint32_t codepoint) {
  if (codepoint < 0x80) {
    output += static_cast<char>(codepoint);
  } else if (codepoint < 0x800) {
    output += static_cast<char>(0xc0 | (codepoint >> 6));
    output += static_cast<char>(0x80 | (codepoint & 0x3f));
  } else {
    output += static_cast<char>(0xe0 | (codepoint >> 12));
    output += static_cast<char>(0x80 | ((codepoint >> 6) & 0x3f));
    output += static_cast<char>(0x80 | (codepoint & 0x3f));
  }
}

uint32_t displayUpper(uint32_t codepoint) {
  switch (codepoint) {
    case 0x2013:
    case 0x2014:
      return '-';
    case 0x2018:
    case 0x2019:
      return '\'';
    case 0x201c:
    case 0x201d:
      return '"';
    case 0x2026:
      return '.';
    case 0x00a0:
      return ' ';
    default:
      return codepoint;
  }
}

}  // namespace

uint32_t nextCodepoint(const String& text, size_t& offset) {
  if (offset >= text.length()) {
    return 0;
  }
  const uint8_t first = static_cast<uint8_t>(text[offset++]);
  if ((first & 0x80) == 0) {
    return first;
  }
  if ((first & 0xe0) == 0xc0 && offset < text.length()) {
    const uint8_t second = static_cast<uint8_t>(text[offset++]);
    return ((first & 0x1f) << 6) | (second & 0x3f);
  }
  if ((first & 0xf0) == 0xe0 && offset + 1 < text.length()) {
    const uint8_t second = static_cast<uint8_t>(text[offset++]);
    const uint8_t third = static_cast<uint8_t>(text[offset++]);
    return ((first & 0x0f) << 12) | ((second & 0x3f) << 6) |
           (third & 0x3f);
  }
  if ((first & 0xf8) == 0xf0 && offset + 2 < text.length()) {
    const uint8_t second = static_cast<uint8_t>(text[offset++]);
    const uint8_t third = static_cast<uint8_t>(text[offset++]);
    const uint8_t fourth = static_cast<uint8_t>(text[offset++]);
    return ((first & 0x07) << 18) | ((second & 0x3f) << 12) |
           ((third & 0x3f) << 6) | (fourth & 0x3f);
  }
  return '?';
}

Glyph glyphFor(uint32_t input) {
  const uint32_t c = displayUpper(input);
  switch (c) {
    case 'A':
      return makeGlyph(5, 0x0e, 0x11, 0x11, 0x1f, 0x11, 0x11, 0x11);
    case 'B':
      return makeGlyph(5, 0x1e, 0x11, 0x11, 0x1e, 0x11, 0x11, 0x1e);
    case 'C':
      return makeGlyph(5, 0x0f, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0f);
    case 'D':
      return makeGlyph(5, 0x1e, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1e);
    case 'E':
      return makeGlyph(5, 0x1f, 0x10, 0x10, 0x1e, 0x10, 0x10, 0x1f);
    case 'F':
      return makeGlyph(5, 0x1f, 0x10, 0x10, 0x1e, 0x10, 0x10, 0x10);
    case 'G':
      return makeGlyph(5, 0x0f, 0x10, 0x10, 0x17, 0x11, 0x11, 0x0f);
    case 'H':
      return makeGlyph(5, 0x11, 0x11, 0x11, 0x1f, 0x11, 0x11, 0x11);
    case 'I':
      return makeGlyph(3, 0x07, 0x02, 0x02, 0x02, 0x02, 0x02, 0x07);
    case 'J':
      return makeGlyph(5, 0x07, 0x02, 0x02, 0x02, 0x12, 0x12, 0x0c);
    case 'K':
      return makeGlyph(5, 0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11);
    case 'L':
      return makeGlyph(5, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1f);
    case 'M':
      return makeGlyph(5, 0x11, 0x1b, 0x15, 0x15, 0x11, 0x11, 0x11);
    case 'N':
      return makeGlyph(5, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11);
    case 'O':
      return makeGlyph(5, 0x0e, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e);
    case 'P':
      return makeGlyph(5, 0x1e, 0x11, 0x11, 0x1e, 0x10, 0x10, 0x10);
    case 'Q':
      return makeGlyph(5, 0x0e, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0d);
    case 'R':
      return makeGlyph(5, 0x1e, 0x11, 0x11, 0x1e, 0x14, 0x12, 0x11);
    case 'S':
      return makeGlyph(5, 0x0f, 0x10, 0x10, 0x0e, 0x01, 0x01, 0x1e);
    case 'T':
      return makeGlyph(5, 0x1f, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04);
    case 'U':
      return makeGlyph(5, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e);
    case 'V':
      return makeGlyph(5, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0a, 0x04);
    case 'W':
      return makeGlyph(5, 0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0a);
    case 'X':
      return makeGlyph(5, 0x11, 0x11, 0x0a, 0x04, 0x0a, 0x11, 0x11);
    case 'Y':
      return makeGlyph(5, 0x11, 0x11, 0x0a, 0x04, 0x04, 0x04, 0x04);
    case 'Z':
      return makeGlyph(5, 0x1f, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1f);
    case 'a':
      return makeGlyph(5, 0x00, 0x00, 0x0e, 0x01, 0x0f, 0x11, 0x0f);
    case 'b':
      return makeGlyph(5, 0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x1e);
    case 'c':
      return makeGlyph(5, 0x00, 0x00, 0x0e, 0x10, 0x10, 0x11, 0x0e);
    case 'd':
      return makeGlyph(5, 0x01, 0x01, 0x0d, 0x13, 0x11, 0x11, 0x0f);
    case 'e':
      return makeGlyph(5, 0x00, 0x00, 0x0e, 0x11, 0x1f, 0x10, 0x0e);
    case 'f':
      return makeGlyph(4, 0x06, 0x09, 0x08, 0x0e, 0x08, 0x08, 0x08);
    case 'g':
      return makeGlyph(5, 0x00, 0x0f, 0x11, 0x11, 0x0f, 0x01, 0x0e);
    case 'h':
      return makeGlyph(5, 0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x11);
    case 'i':
      return makeGlyph(1, 0x01, 0x00, 0x01, 0x01, 0x01, 0x01, 0x01);
    case 'j':
      return makeGlyph(3, 0x01, 0x00, 0x01, 0x01, 0x01, 0x05, 0x02);
    case 'k':
      return makeGlyph(5, 0x10, 0x10, 0x12, 0x14, 0x18, 0x14, 0x12);
    case 'l':
      return makeGlyph(2, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01);
    case 'm':
      return makeGlyph(5, 0x00, 0x00, 0x1a, 0x15, 0x15, 0x15, 0x15);
    case 'n':
      return makeGlyph(5, 0x00, 0x00, 0x16, 0x19, 0x11, 0x11, 0x11);
    case 'o':
      return makeGlyph(5, 0x00, 0x00, 0x0e, 0x11, 0x11, 0x11, 0x0e);
    case 'p':
      return makeGlyph(5, 0x00, 0x1e, 0x11, 0x11, 0x1e, 0x10, 0x10);
    case 'q':
      return makeGlyph(5, 0x00, 0x0f, 0x11, 0x11, 0x0f, 0x01, 0x01);
    case 'r':
      return makeGlyph(4, 0x00, 0x00, 0x0b, 0x0c, 0x08, 0x08, 0x08);
    case 's':
      return makeGlyph(5, 0x00, 0x00, 0x0f, 0x10, 0x0e, 0x01, 0x1e);
    case 't':
      return makeGlyph(4, 0x04, 0x04, 0x0e, 0x04, 0x04, 0x05, 0x02);
    case 'u':
      return makeGlyph(5, 0x00, 0x00, 0x11, 0x11, 0x11, 0x13, 0x0d);
    case 'v':
      return makeGlyph(5, 0x00, 0x00, 0x11, 0x11, 0x11, 0x0a, 0x04);
    case 'w':
      return makeGlyph(5, 0x00, 0x00, 0x11, 0x15, 0x15, 0x15, 0x0a);
    case 'x':
      return makeGlyph(5, 0x00, 0x00, 0x11, 0x0a, 0x04, 0x0a, 0x11);
    case 'y':
      return makeGlyph(5, 0x00, 0x11, 0x11, 0x0f, 0x01, 0x01, 0x0e);
    case 'z':
      return makeGlyph(5, 0x00, 0x00, 0x1f, 0x02, 0x04, 0x08, 0x1f);
    case '0':
      return makeGlyph(5, 0x0e, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0e);
    case '1':
      return makeGlyph(3, 0x02, 0x06, 0x02, 0x02, 0x02, 0x02, 0x07);
    case '2':
      return makeGlyph(5, 0x0e, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1f);
    case '3':
      return makeGlyph(5, 0x1e, 0x01, 0x01, 0x0e, 0x01, 0x01, 0x1e);
    case '4':
      return makeGlyph(5, 0x02, 0x06, 0x0a, 0x12, 0x1f, 0x02, 0x02);
    case '5':
      return makeGlyph(5, 0x1f, 0x10, 0x10, 0x1e, 0x01, 0x01, 0x1e);
    case '6':
      return makeGlyph(5, 0x0e, 0x10, 0x10, 0x1e, 0x11, 0x11, 0x0e);
    case '7':
      return makeGlyph(5, 0x1f, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08);
    case '8':
      return makeGlyph(5, 0x0e, 0x11, 0x11, 0x0e, 0x11, 0x11, 0x0e);
    case '9':
      return makeGlyph(5, 0x0e, 0x11, 0x11, 0x0f, 0x01, 0x01, 0x0e);
    case 0x00c4:  // Ä
      return makeGlyph(5, 0x0a, 0x00, 0x0e, 0x11, 0x1f, 0x11, 0x11);
    case 0x00d6:  // Ö
      return makeGlyph(5, 0x0a, 0x00, 0x0e, 0x11, 0x11, 0x11, 0x0e);
    case 0x00dc:  // Ü
      return makeGlyph(5, 0x0a, 0x00, 0x11, 0x11, 0x11, 0x11, 0x0e);
    case 0x00d5:  // Õ
      return makeGlyph(5, 0x0a, 0x14, 0x0e, 0x11, 0x11, 0x11, 0x0e);
    case 0x0160:  // Š
      return makeGlyph(5, 0x0a, 0x04, 0x0f, 0x10, 0x0e, 0x01, 0x1e);
    case 0x017d:  // Ž
      return makeGlyph(5, 0x0a, 0x04, 0x1f, 0x02, 0x04, 0x08, 0x1f);
    case 0x00e4:  // ä
      return makeGlyph(5, 0x0a, 0x00, 0x0e, 0x01, 0x0f, 0x11, 0x0f);
    case 0x00f6:  // ö
      return makeGlyph(5, 0x0a, 0x00, 0x0e, 0x11, 0x11, 0x11, 0x0e);
    case 0x00fc:  // ü
      return makeGlyph(5, 0x0a, 0x00, 0x11, 0x11, 0x11, 0x13, 0x0d);
    case 0x00f5:  // õ
      return makeGlyph(5, 0x0a, 0x14, 0x0e, 0x11, 0x11, 0x11, 0x0e);
    case 0x0161:  // š
      return makeGlyph(5, 0x0a, 0x04, 0x0f, 0x10, 0x0e, 0x01, 0x1e);
    case 0x017e:  // ž
      return makeGlyph(5, 0x0a, 0x04, 0x1f, 0x02, 0x04, 0x08, 0x1f);
    case 0x00c9:  // É
      return makeGlyph(5, 0x02, 0x04, 0x1f, 0x10, 0x1e, 0x10, 0x1f);
    case 0x00e9:  // é
      return makeGlyph(5, 0x02, 0x04, 0x0e, 0x11, 0x1f, 0x10, 0x0e);
    case ':':
      return makeGlyph(1, 0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00);
    case '.':
      return makeGlyph(1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01);
    case ',':
      return makeGlyph(2, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x02);
    case '-':
      return makeGlyph(3, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00);
    case '+':
      return makeGlyph(5, 0x00, 0x04, 0x04, 0x1f, 0x04, 0x04, 0x00);
    case '%':
      return makeGlyph(5, 0x11, 0x02, 0x04, 0x08, 0x11, 0x00, 0x00);
    case '&':
      return makeGlyph(5, 0x0c, 0x12, 0x14, 0x08, 0x15, 0x12, 0x0d);
    case '/':
      return makeGlyph(5, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10);
    case '\\':
      return makeGlyph(5, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01);
    case '|':
      return makeGlyph(1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01);
    case 0x00ab:  // «
      return makeGlyph(5, 0x00, 0x0a, 0x14, 0x08, 0x14, 0x0a, 0x00);
    case 0x00bb:  // »
      return makeGlyph(5, 0x00, 0x0a, 0x05, 0x02, 0x05, 0x0a, 0x00);
    case 0x00b7:  // ·
      return makeGlyph(1, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00);
    case 0x27e9:  // ⟩
      // Keep this visibly angular.  The old seven-row curve was byte-for-byte
      // identical to ')' and made quoted RSS headlines look malformed.
      return makeGlyph(3, 0x00, 0x04, 0x02, 0x01, 0x02, 0x04, 0x00);
    case '!':
      return makeGlyph(1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x01);
    case '?':
      return makeGlyph(5, 0x0e, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04);
    case '(':
      return makeGlyph(3, 0x01, 0x02, 0x04, 0x04, 0x04, 0x02, 0x01);
    case ')':
      return makeGlyph(3, 0x04, 0x02, 0x01, 0x01, 0x01, 0x02, 0x04);
    case '[':
      return makeGlyph(3, 0x07, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07);
    case ']':
      return makeGlyph(3, 0x07, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07);
    case '\'':
      return makeGlyph(1, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00);
    case '"':
      return makeGlyph(3, 0x05, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00);
    case '#':
      return makeGlyph(5, 0x0a, 0x1f, 0x0a, 0x0a, 0x1f, 0x0a, 0x00);
    case '$':
      return makeGlyph(5, 0x04, 0x0f, 0x14, 0x0e, 0x05, 0x1e, 0x04);
    case 0x00a3:  // £
      return makeGlyph(5, 0x06, 0x09, 0x08, 0x1e, 0x08, 0x09, 0x16);
    case 0x20ac:  // €
      // Rounded open bowl with two left-extending bars, based on the much
      // clearer 8x8 silhouette used by LaMetric icon 13972.
      return makeGlyph(5, 0x06, 0x09, 0x1c, 0x08, 0x1c, 0x09, 0x06);
    case 0x2191:  // ↑
      return makeGlyph(5, 0x04, 0x0e, 0x15, 0x04, 0x04, 0x04, 0x04);
    case 0x2193:  // ↓
      return makeGlyph(5, 0x04, 0x04, 0x04, 0x04, 0x15, 0x0e, 0x04);
    case 0x00b0:
      return makeGlyph(3, 0x02, 0x05, 0x02, 0x00, 0x00, 0x00, 0x00);
    case ' ':
      return makeGlyph(3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00);
    default:
      return makeGlyph(5, 0x1f, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04);
  }
}

Glyph clockGlyphFor(uint32_t codepoint) {
  // The regular font's five-column numerals are useful in scrolling text but
  // make a five-character time wider than the clock's icon-and-text area.
  // These three-column, seven-row figures keep every HH:MM value on one line.
  switch (codepoint) {
    case '0':
      return makeGlyph(3, 0x07, 0x05, 0x05, 0x05, 0x05, 0x05, 0x07);
    case '1':
      return makeGlyph(3, 0x02, 0x06, 0x02, 0x02, 0x02, 0x02, 0x07);
    case '2':
      return makeGlyph(3, 0x07, 0x01, 0x01, 0x07, 0x04, 0x04, 0x07);
    case '3':
      return makeGlyph(3, 0x07, 0x01, 0x01, 0x07, 0x01, 0x01, 0x07);
    case '4':
      return makeGlyph(3, 0x05, 0x05, 0x05, 0x07, 0x01, 0x01, 0x01);
    case '5':
      return makeGlyph(3, 0x07, 0x04, 0x04, 0x07, 0x01, 0x01, 0x07);
    case '6':
      return makeGlyph(3, 0x07, 0x04, 0x04, 0x07, 0x05, 0x05, 0x07);
    case '7':
      return makeGlyph(3, 0x07, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02);
    case '8':
      return makeGlyph(3, 0x07, 0x05, 0x05, 0x07, 0x05, 0x05, 0x07);
    case '9':
      return makeGlyph(3, 0x07, 0x05, 0x05, 0x07, 0x01, 0x01, 0x07);
    case ':':
      return makeGlyph(1, 0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00);
    case ' ':
      return makeGlyph(1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00);
    default:
      return glyphFor(codepoint);
  }
}

int16_t measureText(const String& text) {
  size_t offset = 0;
  int16_t width = 0;
  while (offset < text.length()) {
    const Glyph glyph = glyphFor(nextCodepoint(text, offset));
    width += glyph.width + 1;
  }
  return width > 0 ? width - 1 : 0;
}

int16_t measureClockText(const String& text) {
  size_t offset = 0;
  int16_t width = 0;
  while (offset < text.length()) {
    const Glyph glyph = clockGlyphFor(nextCodepoint(text, offset));
    width += glyph.width + 1;
  }
  return width > 0 ? width - 1 : 0;
}

String uppercaseForDisplay(const String& text) {
  String output;
  output.reserve(text.length());
  size_t offset = 0;
  while (offset < text.length()) {
    appendCodepoint(output, displayUpper(nextCodepoint(text, offset)));
  }
  return output;
}

}  // namespace pixelos
